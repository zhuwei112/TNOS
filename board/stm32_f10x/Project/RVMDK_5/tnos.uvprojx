# Keil uVision project tnos.uvprojx, settings and files
target tnos (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ISO-STM32
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\User\BSP;..\..\..\stm32_f10x;..\..\..\..\tnos;..\..\..\..\tnos\lib_cpu\arm\cortex-m3;..\..\..\..\tnos\souce;..\..\..\..\tnos\utility
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group tnos
    ../../../../tnos/: tnos_test.c
    ../../../../tnos/souce/: tnos_sem.c tnos_mutex.c tnos_core.c tnos_msgq.c tnos_msgcyc.c
    ../../../../tnos/lib_cpu/arm/cortex-m3/: tnos_cpu_c.c
    ../../../../tnos/utility/: clist.c xprintf.c xtimer.c xutils.c
  group main
    ../../: main.c stm32f10x_it.c system_init.c tnos_dev.c
    ../../../../tnos/lib_cpu/arm/cortex-m3/: tnos_cpu_rvds.S
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
